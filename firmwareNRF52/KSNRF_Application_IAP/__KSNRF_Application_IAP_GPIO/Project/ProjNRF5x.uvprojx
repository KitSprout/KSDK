# Keil uVision project ProjNRF5x.uvprojx, settings and files
target NRF52832 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.15.2
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: NRF52832 +hex
  AfterMake: fromelf --bin ".\Obj\@L.axf" --output ".\Obj\@L.bin"
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: NRF52, NRF52832, ARM_MATH_CM4, __FPU_PRESENT = 1
  c include: ..\;..\Libraries\CMSIS;..\Libraries\nRF_Components;..\Libraries\nRF_Components\nRF_Device;..\Libraries\nRF_Components\nRF_Drivers;..\Libraries\nRF_Components\nRF_Drivers\inc;..\Libraries\nRF_Components\nRF_Libraries;..\Libraries\nRF_Components\nRF_Libraries\inc;..\Program
  library: MicroLIB
  memory RVCT4: ROM 0x4000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group CMSIS
    ../Libraries/CMSIS/: arm_startup_nrf52.s system_nrf52.c
  group Driver
    ../Program/drivers/: nrf5x_clock.c nrf5x_delay.c
    ../Program/: nrf5x_conf.h
  group Program
    ../Program/: main.c nrf5x_bsp.c nrf5x_it.c boardConfig.h
  group nRF_Drivers
    ../Libraries/nRF_Components/nRF_Drivers/: nrf_drv_common.c
  group nRF_Libraries
    ../Libraries/nRF_Components/nRF_Libraries/util/: sdk_errors.c
    ../Libraries/nRF_Components/: sdk_config.h
software components: CMSIS:CORE 5.0.2
