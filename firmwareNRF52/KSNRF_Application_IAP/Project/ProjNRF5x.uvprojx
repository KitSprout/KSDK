# Keil uVision project ProjNRF5x.uvprojx, settings and files
target NRF52832 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.15.2
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: NRF52832 +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: NRF52, NRF52832, ARM_MATH_CM4, __FPU_PRESENT = 1
  c include: ..\;..\Libraries\CMSIS;..\Libraries\nRF_Components;..\Libraries\nRF_Components\nRF_Device;..\Libraries\nRF_Components\nRF_Drivers;..\Libraries\nRF_Components\nRF_Drivers\inc;..\Libraries\nRF_Components\nRF_Libraries;..\Libraries\nRF_Components\nRF_Libraries\inc;..\Program;..\Libraries\nRF_Components\nRF_Libraries\bootloader;..\Libraries\nRF_Components\nRF_Libraries\bootloader\dfu;..\Libraries\nRF_Components\nRF_Libraries\bootloader\ble_dfu
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group CMSIS
    ../Libraries/CMSIS/: arm_startup_nrf52.s system_nrf52.c
  group Driver
    ../Program/drivers/: nrf5x_clock.c nrf5x_flash.c nrf5x_delay.c nrf5x_uart.c
    ../Program/: nrf5x_conf.h
  group Program
    ../Program/: main.c nrf5x_bsp.c nrf5x_bootloader.c nrf5x_it.c boardConfig.h
  group Module
    ../Program/modules/: serial.c
  group nRF_Drivers
    ../Libraries/nRF_Components/nRF_Drivers/: nrf_drv_common.c
  group nRF_Libraries
    ../Libraries/nRF_Components/nRF_Libraries/util/: sdk_errors.c
    ../Libraries/nRF_Components/: sdk_config.h
software components: CMSIS:CORE 5.0.2
